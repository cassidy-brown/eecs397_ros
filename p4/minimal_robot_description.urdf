Commit message: p4

File: p4/minimal_robot_description.urdf (robot description, URDF)
Before this commit: robot two_DOF_robot, 4 links, 3 joints
Links:
- link link3: geometry collision cylinder length=1 radius=0.07; visual cylinder length=1 radius=0.07
Joints:
- joint joint2: axis 0 1 0 -> 1 0 0
